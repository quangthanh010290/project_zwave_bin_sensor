# Keil uVision project ButtonSensors.uvproj, settings and files
target Release (MCS-51)
  device: ZW0301 Sigma Designs
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x7FFF) CLOCK(16000000)
  output: /3buttons_ZW030x_US +hex
  c flags: Optimize=12
  c define: ZW_SLAVE,ZW_SLAVE_ROUTING,ZW_SLAVE_32,ZW030x,ZW_ZENSOR,ZW_SELF_HEAL,NOZW_DEBUG,US,NON_BATT,ZW_ROUTING_CONTROL, ZW_DEBUG
  c misc: DB OE NOCO SB LC CD
  c include: ..\..\Z-Wave\IO_Defines;..\..\Z-Wave\include;..\Util_Func;..\3Buttons_Bin
  asm misc: NORB DF(ZW_SLAVE,ZW_SLAVE_ROUTING,ZW_SLAVE_32,ZW030x,ZW_ZENSOR,ZW_SELF_HEAL,NOZW_DEBUG,US,NON_BATT,ZW_ROUTING_CONTROL)
  asm include: ..\..\Z-Wave\IO_Defines;..\..\Z-Wave\include;..\Util_Func
  link misc: DW (13,16,25) NOOL CLASSES(IDATA(D:0-D:0xff),XDATA(X:0-X:0x7ff),CODE(C:0-C:0x7fff))
SEGMENTS(?CO?ZW_RF020X_FTBL (C:0X7F80))
  group Appl Source Code
    ./: eeprom.h Switch3.c Switch3.h MyButtons.c MyButtons.h
    ../Util_Func/: slave_learn.h slave_learn.c
    ../util_func/: self_heal.h self_heal.c association.h association.c
    ../../Z-Wave/IO_defines/: App_RFSetup.a51
  group Z-Wave Lib
    ../../Z-Wave/rf_freq/: ZW_rf_030x_US.obj
    ../../Z-Wave/lib/slave_enhanced_ZW030x/: zw_slave_enhanced_ZW030xs.lib
  group Z-Wave Inc
    ../../Z-Wave/include/: ZW020x.h ZW030x.h ZW_adcdriv_api.h ZW_appltimer.h ZW_basis_api.h ZW_classcmd.h ZW_controller_api.h ZW_controller_bridge_api.h ZW_controller_installer_api.h ZW_controller_static_api.h ZW_debug_api.h ZW_eep_addr.h ZW_mem_api.h ZW_nodemask_api.h ZW_non_zero.h ZW_power_api.h ZW_RF020x.h ZW_RF030x.h ZW_sensor_api.h ZW_SerialAPI.h ZW_slave_32_api.h ZW_slave_api.h ZW_slave_routing_api.h ZW_sysdefs.h ZW_timer_api.h ZW_transport_api.h ZW_triac_api.h ZW_typedefs.h ZW_uart_api.h
